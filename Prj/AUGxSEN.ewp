# IAR project AUGxSEN.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\App\Inc; ..\Board\Inc; ..\Chip\inc; ..\Chip\inc\IAR; ..\Chip\inc\kinetis; ..\Lib\CMSIS\Inc; ..\Lib\FatFs; ..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: AUGxSEN.out
  ILINK.IlinkIcfFile: config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
configuration ram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: D:\freescale\AUGxK60\config files\128KB_Ram.icf
  group APP
    ../Board/inc/: FIRE_PORT_cfg.h
    ../App/: main.c MK60_it.c
  group BOARD
    ../Board/src/: FIRE_ASCII.c FIRE_camera.c FIRE_key.c FIRE_LED.C FIRE_MK60_conf.c FIRE_OV7725_Eagle.c FIRE_SCCB.c Key.c oled.c PWM.c tower.c var.c
  group CHIP
    ../Chip/inc/: common.h
    ../Chip/src/: misc.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/CMSIS
    ../Lib/CMSIS/: iar_cortexM4l_math.a
